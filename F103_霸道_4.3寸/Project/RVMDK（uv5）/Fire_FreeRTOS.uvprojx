# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Fire_FreeRTOS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=2 uC99=1
  c define: STM32F10X_HD,X_GUI_USE_FREERTOS,USE_STDPERIPH_DRIVER,
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\led;..\..\User\usart;..\..\User\Key;..\..\User\liuwei;..\..\User\liuwei\drv_inc;..\..\User\liuwei\spi_flash;..\..\User\liuwei\System_Drv;..\..\User\liuwei\X_GUI_Drv;..\..\..\emXGUI_Lib\drv;..\..\..\emXGUI_Lib\app\base;..\..\..\emXGUI_Lib\arch\Inc;..\..\..\emXGUI_Lib;..\..\User\bsp;..\..\..\..\..\emXGUI_Lib\arch;..\..\User\bsp\drv_inc;..\..\User\bsp\X_GUI_Drv;..\..\User\bsp\FATFS;..\..\User\bsp\FATFS\option;..\..\..\emXGUI_Lib\inc;..\..\..\emXGUI_Lib\arch;..\..\User\App\Board_App;..\..\User\App\Board_App\mp3_player\vs1053;..\..\User\App\Board_App\SimulateUDisk\Mass_Storage\inc;..\..\User\App\Board_App\SimulateUDisk\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\Output\Fire_FreeRTOS.sct
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h FreeRTOSConfig.h stm32f10x_it.c stm32f10x_it.h
  group BSP
    ../../User/bsp/usart/: bsp_usart.c
    ../../User/bsp/spi_flash/: bsp_flash_spi.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/Key/: bsp_key.c
    ../../User/bsp/touch/: bsp_i2c_touch.c gt9xx.c gt5xx.c
    ../../User/bsp/dwt_delay/: core_delay.c
    ../../User/bsp/sdio/: bsp_sdio_sdcard.c
    ../../User/bsp/fsmc/: bsp_fsmc.c
    ../../User/bsp/LCD/: NT35510_16Bit.c ILI9806_16Bit.c
    ../../User/bsp/EEPROM/: bsp_i2c_ee.c bsp_i2c_gpio_ee.c
    ../../User/bsp/beep/: bsp_beep.c
  group Fatfs
    ../../User/bsp/FATFS/: ff.c diskio.c
    ../../User/bsp/FATFS/option/: cc936.c extern_cc936.c syscall.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group OEM_Face
    ../../../emXGUI_Lib/OEM_Face/: OEM_Button.c OEM_CheckBox.c OEM_GroupBox.c OEM_ListBox.c OEM_ProgressBar.c OEM_RadioBox.c OEM_ScrollBar.c OEM_TextBox.c
  group emxgui/arch
    ../../../emXGUI_Lib/arch/: GUI_Arch.c GUI_GPU.c EXT_LCD_Arch.c
    ../../../emXGUI_Lib/arch/OS_Options/: X_GUI_FreeRTOS.c
    ../../../emXGUI_Lib/arch/Inc/: gui_drv.h gui_os_port.h
  group emxgui/resource
    ../../../emXGUI_Lib/resource/xft_font/: ASCII_16_4BPP.c ASCII_20_4BPP.c ASCII_24_4BPP.c GB2312_16_2BPP.c
  group emxgui/drv
    ../../User/: gui_drv_cfg.h
    ../../../emXGUI_Lib/drv/: gui_font_port.c gui_fs_port.c gui_input_port.c gui_lcd_port.c gui_log_port.c gui_mem_port.c gui_resource_port.c gui_startup.c gui_touch_port.c gui_picture_port.c
  group emxgui/inc
    ../../../emXGUI_Lib/inc/: def.h x_obj.h x_libc.h GUI_Font_XFT.h Web_Color.h emXGUI_Arch.h emXGUI.h
  group emxgui/libs
    ../../../emXGUI_Lib/libs/: emXGUI100_MDK_M3.lib x_libc_MDK_M3.lib libpng_MDK_CM3.lib x_obj.cpp
  group base_app
    ../../../emXGUI_Lib/app/base/: gui_desktop.c
    ../../../emXGUI_Lib/app/base/boot_interface/: GUI_Boot_Interface_Dialog.c
    ../../../emXGUI_Lib/app/base/res_writer/: backend_res_writer.c GUI_RES_Writer_Dialog.c
  group app_res
    ../../../emXGUI_Lib/app/base/boot_interface/: boot_logo.c
  group gui_app
    ../../User/App/Board_App/: GUI_Board_App_Desktop.c
    ../../User/App/GUI_Demo/: CListMenu.cpp GUI_App_Desktop.c GUI_DEMO_ShowWave.cpp GUI_DEMO_Settings.c calculator.cpp GUI_SelectDialogBox.c GUI_DEMO_Number_Keyboard.c
  group tutorial/music_record
    ../../User/App/Board_App/mp3_player/vs1053/: VS1053.c
    ../../User/App/Board_App/mp3_player/: Backend_mp3Player.c GUI_MUSICPLAYER_DIALOG.c GUI_MusicList_DIALOG.c
    ../../User/App/Board_App/recorder/: GUI_RECORDER_DIALOG.c Backend_Recorder.c
  group tutorial/led_key
    ../../User/App/Board_App/LED_Key/: GUI_LED_KEY_Dialog.c
  group STM32_USB-FS-Device_Driver
    ../../User/App/Board_App/SimulateUDisk/STM32_USB-FS-Device_Driver/src/: usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c usb_core.c
  group Mass_Storage
    ../../User/App/Board_App/SimulateUDisk/Mass_Storage/src/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group tutorial/U_Disk
    ../../User/App/Board_App/SimulateUDisk/: GUI_SimulateUDisk_Dialog.c
  group tutorial/network
    ../../User/App/Board_App/network/: GUI_network_Dialog.c
    ../../User/App/Board_App/network/W5500/: w5500.c w5500_conf.c utility.c socket.c
    ../../User/App/Board_App/network/W5500/dhcp/: dhcp.c
    ../../User/App/Board_App/network/TimBase/: bsp_TiMbase.c
  group tutorial/T_RH
    ../../User/App/Board_App/T_RH/: GUI_T_RH_Dialog.c
    ../../User/App/Board_App/T_RH/dht11/: bsp_dht11.c
  group tutorial/beeper
    ../../User/App/Board_App/beeper_control/: GUI_Beeper_Dialog.c
  group tutorial/adc
    ../../User/App/Board_App/adc_Collect_voltage/: GUI_ADC_CollectVoltage_Dialog.c bsp_adc.c
  group tutorial/Phone_SMS
    ../../User/App/Board_App/Phone_SMS/: GUI_Phone_Dialog.c GUI_SMS_Dialog.c
    ../../User/App/Board_App/Phone_SMS/sim900a/: bsp_sim900a.c bsp_gsm_usart.c
  group tutorial/rgbled
    ../../User/App/Board_App/rgb_led/: Backend_RGBLED.c GUI_RGBLED_DIALOG.c
  group tutorial/camera
    ../../User/App/Board_App/camera/: GUI_Camera_Dialog.c
    ../../User/App/Board_App/camera/ov7725/: bsp_ov7725.c bsp_sccb.c
  group tutorial/Wi-Fi
    ../../User/App/Board_App/WiFi/: GUI_WiFi_Dialog.c
    ../../User/App/Board_App/WiFi/ESP8266/: bsp_esp8266.c
  group tutorial/clock
    ../../User/App/Board_App/clock/: GUI_CLOCK_DIALOG.c
    ../../User/App/Board_App/clock/rtc/: bsp_date.c bsp_rtc.c
  group DOC
    ../../Doc/: readme.txt
